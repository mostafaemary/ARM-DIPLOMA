# Keil uVision project hell.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bedan
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.6.0, Test:Unity 2.5.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:ADC 1.8.1, Device:STM32Cube HAL:CRC 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:EXTI 1.8.1, Device:STM32Cube HAL:Flash 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:HCD 1.8.1, Device:STM32Cube HAL:I2C 1.8.1, Device:STM32Cube HAL:I2S 1.8.1, Device:STM32Cube HAL:IRDA 1.8.1, Device:STM32Cube HAL:IWDG 1.8.1, Device:STM32Cube HAL:MMC 1.8.1, Device:STM32Cube HAL:PCD 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:RTC 1.8.1, Device:STM32Cube HAL:SD 1.8.1, Device:STM32Cube HAL:SMBUS 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:Smartcard 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:STM32Cube HAL:WWDG 1.8.1, Device:STM32Cube LL:Common 1.8.1, Device:STM32Cube LL:GPIO 1.8.1, Device:STM32Cube LL:PWR 1.8.1, Device:STM32Cube LL:RCC 1.8.1, Device:STM32Cube LL:UTILS 1.8.1, Device:Startup 2.6.3
